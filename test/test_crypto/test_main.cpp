#include <unity.h>
#include <cstring>
#include <cstdio>
#include <input_control/crypto/ChaCha20Poly1305.h>

using namespace input_control::crypto;

void setUp() {}
void tearDown() {}

// Vectores de la RFC 8439 (ChaCha20 and Poly1305 for IETF Protocols), copiados del texto
// oficial: https://www.rfc-editor.org/rfc/rfc8439.txt

// ── §2.3.2 función de bloque de ChaCha20 ─────────────────────────────────────
void test_chacha20_block_matches_rfc8439_2_3_2() {
    uint8_t key[32];
    for (int i = 0; i < 32; ++i) key[i] = (uint8_t)i;
    const uint8_t nonce[12] = {0x00, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x4a, 0x00, 0x00, 0x00, 0x00};
    const uint8_t expected[64] = {
        0x10, 0xf1, 0xe7, 0xe4, 0xd1, 0x3b, 0x59, 0x15, 0x50, 0x0f, 0xdd, 0x1f, 0xa3, 0x20, 0x71, 0xc4,
        0xc7, 0xd1, 0xf4, 0xc7, 0x33, 0xc0, 0x68, 0x03, 0x04, 0x22, 0xaa, 0x9a, 0xc3, 0xd4, 0x6c, 0x4e,
        0xd2, 0x82, 0x64, 0x46, 0x07, 0x9f, 0xaa, 0x09, 0x14, 0xc2, 0xd7, 0x05, 0xd9, 0x8b, 0x02, 0xa2,
        0xb5, 0x12, 0x9c, 0xd1, 0xde, 0x16, 0x4e, 0xb9, 0xcb, 0xd0, 0x83, 0xe8, 0xa2, 0x50, 0x3c, 0x4e};
    uint8_t out[64] = {};
    chacha20Block(key, 1, nonce, out);
    TEST_ASSERT_EQUAL_HEX8_ARRAY(expected, out, 64);
}

// ── §2.5.2 Poly1305 ──────────────────────────────────────────────────────────
void test_poly1305_matches_rfc8439_2_5_2() {
    const uint8_t key[32] = {
        0x85, 0xd6, 0xbe, 0x78, 0x57, 0x55, 0x6d, 0x33, 0x7f, 0x44, 0x52, 0xfe, 0x42, 0xd5, 0x06, 0xa8,
        0x01, 0x03, 0x80, 0x8a, 0xfb, 0x0d, 0xb2, 0xfd, 0x4a, 0xbf, 0xf6, 0xaf, 0x41, 0x49, 0xf5, 0x1b};
    const char* msg = "Cryptographic Forum Research Group";
    const uint8_t expected[16] = {
        0xa8, 0x06, 0x1d, 0xc1, 0x30, 0x51, 0x36, 0xc6, 0xc2, 0x2b, 0x8b, 0xaf, 0x0c, 0x01, 0x27, 0xa9};
    uint8_t tag[16] = {};
    poly1305(key, (const uint8_t*)msg, 34, tag);
    TEST_ASSERT_EQUAL_HEX8_ARRAY(expected, tag, 16);
}

// ── Apéndice A.3: casos límite de Poly1305 (vectores #5 a #10) ───────────────
// Ejercitan la reducción final y los acarreos, que los vectores "normales" no tocan.
struct PolyEdge { uint8_t r[16]; uint8_t s[16]; uint8_t data[64]; size_t len; uint8_t tag[16]; };
static const PolyEdge kEdges[] = {
    // #5: reducción parcial de 130 bits que no queda totalmente reducida
    {{0x02}, {0x00},
     {0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF}, 16,
     {0x03}},
    // #6: la suma de s desborda 2^128
    {{0x02}, {0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF},
     {0x02}, 16,
     {0x03}},
    // #7: limbo de datos todo en unos con acarreo
    {{0x01}, {0x00},
     {0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,
      0xF0,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,
      0x11}, 48,
     {0x05}},
    // #8: el resultado del polinomio es exactamente 2^130-5
    {{0x01}, {0x00},
     {0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,
      0xFB,0xFE,0xFE,0xFE,0xFE,0xFE,0xFE,0xFE,0xFE,0xFE,0xFE,0xFE,0xFE,0xFE,0xFE,0xFE,
      0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01}, 48,
     {0x00}},
    // #9: el resultado del polinomio es exactamente 2^130-6
    {{0x02}, {0x00},
     {0xFD,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF}, 16,
     {0xFA,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF}},
    // #10: la reducción 5*H+L da un intermedio de 131 bits
    {{0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04}, {0x00},
     {0xE3,0x35,0x94,0xD7,0x50,0x5E,0x43,0xB9,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
      0x33,0x94,0xD7,0x50,0x5E,0x43,0x79,0xCD,0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
      0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
      0x01}, 64,
     {0x14,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x55}},
};
void test_poly1305_edge_cases_from_rfc8439_appendix_a3() {
    int n = 5;
    for (const PolyEdge& e : kEdges) {
        uint8_t key[32];
        std::memcpy(key, e.r, 16);
        std::memcpy(key + 16, e.s, 16);
        uint8_t tag[16] = {};
        poly1305(key, e.data, e.len, tag);
        char msg[24];
        snprintf(msg, sizeof(msg), "vector #%d", n++);
        TEST_ASSERT_EQUAL_HEX8_ARRAY_MESSAGE(e.tag, tag, 16, msg);
    }
}

// ── §2.8.2 AEAD_CHACHA20_POLY1305 ────────────────────────────────────────────
static const char* kPlain =
    "Ladies and Gentlemen of the class of '99: If I could offer you only one tip for the "
    "future, sunscreen would be it.";
static const size_t kPlainLen = 114;
static const uint8_t kAad[12] = {0x50, 0x51, 0x52, 0x53, 0xc0, 0xc1, 0xc2, 0xc3, 0xc4, 0xc5, 0xc6, 0xc7};
static const uint8_t kNonce[12] = {0x07, 0x00, 0x00, 0x00, 0x40, 0x41, 0x42, 0x43, 0x44, 0x45, 0x46, 0x47};
static const uint8_t kCipher[114] = {
    0xd3, 0x1a, 0x8d, 0x34, 0x64, 0x8e, 0x60, 0xdb, 0x7b, 0x86, 0xaf, 0xbc, 0x53, 0xef, 0x7e, 0xc2,
    0xa4, 0xad, 0xed, 0x51, 0x29, 0x6e, 0x08, 0xfe, 0xa9, 0xe2, 0xb5, 0xa7, 0x36, 0xee, 0x62, 0xd6,
    0x3d, 0xbe, 0xa4, 0x5e, 0x8c, 0xa9, 0x67, 0x12, 0x82, 0xfa, 0xfb, 0x69, 0xda, 0x92, 0x72, 0x8b,
    0x1a, 0x71, 0xde, 0x0a, 0x9e, 0x06, 0x0b, 0x29, 0x05, 0xd6, 0xa5, 0xb6, 0x7e, 0xcd, 0x3b, 0x36,
    0x92, 0xdd, 0xbd, 0x7f, 0x2d, 0x77, 0x8b, 0x8c, 0x98, 0x03, 0xae, 0xe3, 0x28, 0x09, 0x1b, 0x58,
    0xfa, 0xb3, 0x24, 0xe4, 0xfa, 0xd6, 0x75, 0x94, 0x55, 0x85, 0x80, 0x8b, 0x48, 0x31, 0xd7, 0xbc,
    0x3f, 0xf4, 0xde, 0xf0, 0x8e, 0x4b, 0x7a, 0x9d, 0xe5, 0x76, 0xd2, 0x65, 0x86, 0xce, 0xc6, 0x4b,
    0x61, 0x16};
static const uint8_t kTag[16] = {
    0x1a, 0xe1, 0x0b, 0x59, 0x4f, 0x09, 0xe2, 0x6a, 0x7e, 0x90, 0x2e, 0xcb, 0xd0, 0x60, 0x06, 0x91};

static void rfcKey(uint8_t key[32]) {
    for (int i = 0; i < 32; ++i) key[i] = (uint8_t)(0x80 + i);
}

void test_aead_seal_matches_rfc8439_2_8_2() {
    uint8_t key[32]; rfcKey(key);
    uint8_t ct[114] = {}; uint8_t tag[16] = {};
    aeadSeal(key, kNonce, kAad, sizeof(kAad), (const uint8_t*)kPlain, kPlainLen, ct, tag);
    TEST_ASSERT_EQUAL_HEX8_ARRAY(kCipher, ct, 114);
    TEST_ASSERT_EQUAL_HEX8_ARRAY(kTag, tag, 16);
}
void test_aead_open_recovers_the_plaintext() {
    uint8_t key[32]; rfcKey(key);
    uint8_t pt[114] = {};
    TEST_ASSERT_TRUE(aeadOpen(key, kNonce, kAad, sizeof(kAad), kCipher, 114, kTag, pt));
    TEST_ASSERT_EQUAL_UINT8_ARRAY((const uint8_t*)kPlain, pt, 114);
}
void test_aead_open_rejects_modified_ciphertext() {
    uint8_t key[32]; rfcKey(key);
    uint8_t ct[114]; std::memcpy(ct, kCipher, 114);
    ct[50] ^= 0x01;
    uint8_t pt[114] = {};
    TEST_ASSERT_FALSE(aeadOpen(key, kNonce, kAad, sizeof(kAad), ct, 114, kTag, pt));
}
void test_aead_open_rejects_modified_tag() {
    uint8_t key[32]; rfcKey(key);
    uint8_t tag[16]; std::memcpy(tag, kTag, 16);
    tag[15] ^= 0x80;
    uint8_t pt[114] = {};
    TEST_ASSERT_FALSE(aeadOpen(key, kNonce, kAad, sizeof(kAad), kCipher, 114, tag, pt));
}
void test_aead_open_rejects_modified_aad() {
    uint8_t key[32]; rfcKey(key);
    uint8_t aad[12]; std::memcpy(aad, kAad, 12);
    aad[0] ^= 0x01;
    uint8_t pt[114] = {};
    TEST_ASSERT_FALSE(aeadOpen(key, kNonce, aad, sizeof(aad), kCipher, 114, kTag, pt));
}
void test_aead_open_rejects_another_key() {
    uint8_t key[32]; rfcKey(key);
    key[0] ^= 0x01;
    uint8_t pt[114] = {};
    TEST_ASSERT_FALSE(aeadOpen(key, kNonce, kAad, sizeof(kAad), kCipher, 114, kTag, pt));
}
void test_aead_open_rejects_another_nonce() {
    uint8_t key[32]; rfcKey(key);
    uint8_t nonce[12]; std::memcpy(nonce, kNonce, 12);
    nonce[11] ^= 0x01;
    uint8_t pt[114] = {};
    TEST_ASSERT_FALSE(aeadOpen(key, nonce, kAad, sizeof(kAad), kCipher, 114, kTag, pt));
}
// Si la verificación falla no se entrega NADA del texto: el buffer de salida no se toca.
void test_aead_open_does_not_release_plaintext_on_failure() {
    uint8_t key[32]; rfcKey(key);
    uint8_t tag[16]; std::memcpy(tag, kTag, 16);
    tag[0] ^= 0x01;
    uint8_t pt[114];
    std::memset(pt, 0xEE, sizeof(pt));
    TEST_ASSERT_FALSE(aeadOpen(key, kNonce, kAad, sizeof(kAad), kCipher, 114, tag, pt));
    for (size_t i = 0; i < sizeof(pt); ++i) TEST_ASSERT_EQUAL_HEX8(0xEE, pt[i]);
}
void test_aead_roundtrip_with_empty_plaintext_and_aad() {
    uint8_t key[32]; rfcKey(key);
    uint8_t tag[16] = {};
    aeadSeal(key, kNonce, nullptr, 0, nullptr, 0, nullptr, tag);
    TEST_ASSERT_TRUE(aeadOpen(key, kNonce, nullptr, 0, nullptr, 0, tag, nullptr));
    tag[3] ^= 0x10;
    TEST_ASSERT_FALSE(aeadOpen(key, kNonce, nullptr, 0, nullptr, 0, tag, nullptr));
}
// Tamaños típicos de los paquetes de la sala: 2, 5 y 8 bytes de carga, 11 de cabecera.
void test_aead_roundtrip_with_short_payloads() {
    uint8_t key[32]; rfcKey(key);
    const uint8_t aad[11] = {0x4C, 2, 0x10, 17, 19, 1, 0, 9, 0, 0, 0};
    const size_t sizes[] = {1, 2, 5, 8, 16, 17, 37};
    for (size_t n : sizes) {
        uint8_t pt[40], ct[40], back[40], tag[16];
        for (size_t i = 0; i < n; ++i) pt[i] = (uint8_t)(0xA0 + i);
        aeadSeal(key, kNonce, aad, sizeof(aad), pt, n, ct, tag);
        TEST_ASSERT_TRUE(aeadOpen(key, kNonce, aad, sizeof(aad), ct, n, tag, back));
        TEST_ASSERT_EQUAL_UINT8_ARRAY(pt, back, n);
    }
}

int main(int, char**) {
    UNITY_BEGIN();
    RUN_TEST(test_chacha20_block_matches_rfc8439_2_3_2);
    RUN_TEST(test_poly1305_matches_rfc8439_2_5_2);
    RUN_TEST(test_poly1305_edge_cases_from_rfc8439_appendix_a3);
    RUN_TEST(test_aead_seal_matches_rfc8439_2_8_2);
    RUN_TEST(test_aead_open_recovers_the_plaintext);
    RUN_TEST(test_aead_open_rejects_modified_ciphertext);
    RUN_TEST(test_aead_open_rejects_modified_tag);
    RUN_TEST(test_aead_open_rejects_modified_aad);
    RUN_TEST(test_aead_open_rejects_another_key);
    RUN_TEST(test_aead_open_rejects_another_nonce);
    RUN_TEST(test_aead_open_does_not_release_plaintext_on_failure);
    RUN_TEST(test_aead_roundtrip_with_empty_plaintext_and_aad);
    RUN_TEST(test_aead_roundtrip_with_short_payloads);
    return UNITY_END();
}
